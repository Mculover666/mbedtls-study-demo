# Keil uVision project mbedtls-BearPi-MDK.uvprojx, settings and files
target mbedtls-BearPi-MDK (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: mbedtls-BearPi-MDK +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MBEDTLS_CONFIG_FILE=<mbedtls_config_x509.h>,USE_HAL_DRIVER,STM32L431xx
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\mbedtls\include\;..\mbedtls\config;..\mbedtls_demo\demo_config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User
    ../Src/: main.c gpio.c dma.c rng.c sys.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rng.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group mbedtls/libraries
    ../mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/config
    ../mbedtls/config/: config-mini-tls1_1.h
    ../mbedtls_demo/demo_config/: mbedtls_config_ctr_drbg.h mbedtls_config_sha_x.h mbedtls_config_aes.h mbedtls_config_hmac.h mbedtls_config_gcm.h mbedtls_config_rsa.h mbedtls_config_dhm.h mbedtls_config_ecdh.h mbedtls_config_rsa_sign.h mbedtls_config_ecdsa.h mbedtls_config_x509.h
  group mbedtls/port
    ../mbedtls/port/: entropy_hardware_alt.c
  group mbedtls/demo
    ../mbedtls_demo/demo_src/: mbedtls_ctr_drbg_test.c mbedtls_sha_x_test.c mbedtls_aes_test.c mbedtls_hmac_test.c mbedtls_gcm_test.c mbedtls_rsa_test.c mbedtls_dhm_test.c mbedtls_ecdh_test.c mbedtls_rsa_sign_test.c mbedtls_ecdsa_test.c mbedtls_x509_test.c
software components: CMSIS:CORE 4.3.0
